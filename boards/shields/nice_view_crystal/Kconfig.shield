## boards/shields/nice_view_crystal/Kconfig.shield
```kconfig
config SHIELD_NICE_VIEW_CRYSTAL
    def_bool $(shields_list_contains,nice_view_crystal)
```
